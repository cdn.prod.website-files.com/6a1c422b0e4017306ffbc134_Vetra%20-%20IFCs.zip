Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\SOLIDWORKS WORKING\00-KINLEY\BENCHES\BENCH 1.IFC
Time: 2026-05-01T10:11:19+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
SOLIDWORKS Custom Properties - WEIGHT: 40.47
PSet_Mass_Property - Area Measure: 2.7598717755946689; Mass Measure: 40.4713694206852352; Volume Measure: 0.0348259318125328

# IfcBuilding, default Building
SOLIDWORKS Custom Properties - WEIGHT: 40.47
PSet_Mass_Property - Area Measure: 2.7598717755946689; Mass Measure: 40.4713694206852352; Volume Measure: 0.0348259318125328

# IfcBuildingStorey, default BuildingStorey
In: default Building
SOLIDWORKS Custom Properties - WEIGHT: 40.47
PSet_Mass_Property - Area Measure: 2.7598717755946689; Mass Measure: 40.4713694206852352; Volume Measure: 0.0348259318125328

# IfcBuildingElementProxy: AECARCHITECTURALELEMENT (13)
In: default BuildingStorey
SOLIDWORKS Custom Properties - Finish: Unchecked
Name | DESCRIPTION | Material | WEIGHT
Part5^BENCH 1 | Part5^BENCH 1 | MILD STEEL | 0.19
Part5^BENCH 1-1 | Part5^BENCH 1 | MILD STEEL | 0.19
Part1^BENCH 1 | Part1^BENCH 1 | IROKO | 4.27
Part1^BENCH 1-1 | Part1^BENCH 1 | IROKO | 4.27
Part1^BENCH 1-2 | Part1^BENCH 1 | IROKO | 4.27
Part1^BENCH 1-3 | Part1^BENCH 1 | IROKO | 4.27
Part5^BENCH 1-2 | Part5^BENCH 1 | MILD STEEL | 0.19
Part1^BENCH 1-4 | Part1^BENCH 1 | IROKO | 4.27
Part2^BENCH 1 | Part2^BENCH 1 | MILD STEEL | 8.69
Part3^BENCH 1 | Part3^BENCH 1 | MILD STEEL | 0.49
Part3^BENCH 1-1 | Part3^BENCH 1 | MILD STEEL | 0.49
Part2^BENCH 1-1 | Part2^BENCH 1 | MILD STEEL | 8.69
Part5^BENCH 1-3 | Part5^BENCH 1 | MILD STEEL | 0.19

# IfcElementAssembly, BENCH 1
In: default BuildingStorey
SOLIDWORKS Custom Properties - WEIGHT: 40.47
PSet_Mass_Property - Area Measure: 2.7598717755946689; Mass Measure: 40.4713694206852352; Volume Measure: 0.0348259318125328
