Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\SOLIDWORKS WORKING\00-KINLEY\BENCHES\BENCH 6.IFC
Time: 2026-05-01T10:10:24+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
SOLIDWORKS Custom Properties - WEIGHT: 33.39
PSet_Mass_Property - Area Measure: 2.8781137777096668; Mass Measure: 33.3853053904148425; Volume Measure: 0.0339174620650622

# IfcBuilding, default Building
SOLIDWORKS Custom Properties - WEIGHT: 33.39
PSet_Mass_Property - Area Measure: 2.8781137777096668; Mass Measure: 33.3853053904148425; Volume Measure: 0.0339174620650622

# IfcBuildingStorey, default BuildingStorey
In: default Building
SOLIDWORKS Custom Properties - WEIGHT: 33.39
PSet_Mass_Property - Area Measure: 2.8781137777096668; Mass Measure: 33.3853053904148425; Volume Measure: 0.0339174620650622

# IfcBuildingElementProxy: AECARCHITECTURALELEMENT (5)
In: default BuildingStorey
SOLIDWORKS Custom Properties - Finish: Unchecked
Name | DESCRIPTION | Material | WEIGHT
Part6^BENCH 6 | Part6^BENCH 6 | MILD STEEL | 5.52
Part5^BENCH 6 | Part5^BENCH 6 | IROKO | 21.37
Part6^BENCH 6-1 | Part6^BENCH 6 | MILD STEEL | 5.52
Part7^BENCH 6 | Part7^BENCH 6 | MILD STEEL | 0.49
Part7^BENCH 6-1 | Part7^BENCH 6 | MILD STEEL | 0.49

# IfcElementAssembly, BENCH 6
In: default BuildingStorey
SOLIDWORKS Custom Properties - WEIGHT: 33.39
PSet_Mass_Property - Area Measure: 2.8781137777096668; Mass Measure: 33.3853053904148425; Volume Measure: 0.0339174620650622
