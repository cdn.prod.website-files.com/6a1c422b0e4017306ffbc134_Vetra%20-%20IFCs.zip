Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\SOLIDWORKS WORKING\00-KINLEY\BENCHES\BENCH 40.IFC
Time: 2026-05-01T10:09:55+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
SOLIDWORKS Custom Properties - WEIGHT: 52.75
PSet_Mass_Property - Area Measure: 3.6453584473731038; Mass Measure: 52.7499220572746736; Volume Measure: 0.0364001052274801

# IfcBuilding, default Building
SOLIDWORKS Custom Properties - WEIGHT: 52.75
PSet_Mass_Property - Area Measure: 3.6453584473731038; Mass Measure: 52.7499220572746736; Volume Measure: 0.0364001052274801

# IfcBuildingStorey, default BuildingStorey
In: default Building
SOLIDWORKS Custom Properties - WEIGHT: 52.75
PSet_Mass_Property - Area Measure: 3.6453584473731038; Mass Measure: 52.7499220572746736; Volume Measure: 0.0364001052274801

# IfcBuildingElementProxy: AECARCHITECTURALELEMENT (10)
In: default BuildingStorey
SOLIDWORKS Custom Properties - Finish: Unchecked
Name | DESCRIPTION | Material | WEIGHT
Part1^BENCH 40 | Part1^BENCH 40 | IROKO | 4.27
Part1^BENCH 40-1 | Part1^BENCH 40 | IROKO | 4.27
Part1^BENCH 40-2 | Part1^BENCH 40 | IROKO | 4.27
Part1^BENCH 40-3 | Part1^BENCH 40 | IROKO | 4.27
Part2^BENCH 40 | Part2^BENCH 40 | MILD STEEL | 10.64
Part2^BENCH 40-1 | Part2^BENCH 40 | MILD STEEL | 10.64
Part3^BENCH 40 | Part3^BENCH 40 | MILD STEEL | 0.49
Part3^BENCH 40-1 | Part3^BENCH 40 | MILD STEEL | 0.49
Part4^BENCH 40 | Part4^BENCH 40 | MILD STEEL | 9.12
Part1^BENCH 40-4 | Part1^BENCH 40 | IROKO | 4.27

# IfcElementAssembly, BENCH 40
In: default BuildingStorey
SOLIDWORKS Custom Properties - WEIGHT: 52.75
PSet_Mass_Property - Area Measure: 3.6453584473731038; Mass Measure: 52.7499220572746736; Volume Measure: 0.0364001052274801
