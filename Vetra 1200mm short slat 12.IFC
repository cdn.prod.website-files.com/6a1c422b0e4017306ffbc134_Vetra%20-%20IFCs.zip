Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\SOLIDWORKS WORKING\00-KINLEY\BENCHES\BENCH 5.IFC
Time: 2026-05-01T10:10:39+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
SOLIDWORKS Custom Properties - WEIGHT: 47.94
PSet_Mass_Property - Area Measure: 3.5469072985388030; Mass Measure: 47.9393504382464002; Volume Measure: 0.0334318551843906

# IfcBuilding, default Building
SOLIDWORKS Custom Properties - WEIGHT: 47.94
PSet_Mass_Property - Area Measure: 3.5469072985388030; Mass Measure: 47.9393504382464002; Volume Measure: 0.0334318551843906

# IfcBuildingStorey, default BuildingStorey
In: default Building
SOLIDWORKS Custom Properties - WEIGHT: 47.94
PSet_Mass_Property - Area Measure: 3.5469072985388030; Mass Measure: 47.9393504382464002; Volume Measure: 0.0334318551843906

# IfcBuildingElementProxy: AECARCHITECTURALELEMENT (20)
In: default BuildingStorey
SOLIDWORKS Custom Properties - Finish: Unchecked
Name | DESCRIPTION | Material | WEIGHT
Part14^BENCH 5 | Part14^BENCH 5 | IROKO | 1.23
Part14^BENCH 5-1 | Part14^BENCH 5 | IROKO | 1.23
Part14^BENCH 5-2 | Part14^BENCH 5 | IROKO | 1.23
Part14^BENCH 5-3 | Part14^BENCH 5 | IROKO | 1.23
Part14^BENCH 5-4 | Part14^BENCH 5 | IROKO | 1.23
Part14^BENCH 5-5 | Part14^BENCH 5 | IROKO | 1.23
Part14^BENCH 5-6 | Part14^BENCH 5 | IROKO | 1.23
Part14^BENCH 5-7 | Part14^BENCH 5 | IROKO | 1.23
Part14^BENCH 5-8 | Part14^BENCH 5 | IROKO | 1.23
Part14^BENCH 5-9 | Part14^BENCH 5 | IROKO | 1.23
Part14^BENCH 5-10 | Part14^BENCH 5 | IROKO | 1.23
Part14^BENCH 5-11 | Part14^BENCH 5 | IROKO | 1.23
Part14^BENCH 5-12 | Part14^BENCH 5 | IROKO | 1.23
Part15^BENCH 5 | Part15^BENCH 5 | MILD STEEL | 8.71
Part16^BENCH 5 | Part16^BENCH 5 | MILD STEEL | 9.27
Part14^BENCH 5-13 | Part14^BENCH 5 | IROKO | 1.23
Part15^BENCH 5-1 | Part15^BENCH 5 | MILD STEEL | 8.71
Part17^BENCH 5 | Part17^BENCH 5 | MILD STEEL | 1.59
Part14^BENCH 5-14 | Part14^BENCH 5 | IROKO | 1.23
Part14^BENCH 5-15 | Part14^BENCH 5 | IROKO | 1.23

# IfcElementAssembly, BENCH 5
In: default BuildingStorey
SOLIDWORKS Custom Properties - WEIGHT: 47.94
PSet_Mass_Property - Area Measure: 3.5469072985388030; Mass Measure: 47.9393504382464002; Volume Measure: 0.0334318551843906
