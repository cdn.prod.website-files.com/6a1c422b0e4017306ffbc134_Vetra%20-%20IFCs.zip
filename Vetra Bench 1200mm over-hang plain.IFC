Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\SOLIDWORKS WORKING\00-KINLEY\BENCHES\BENCH 2.IFC
Time: 2026-05-01T10:11:08+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
SOLIDWORKS Custom Properties - WEIGHT: 37.59
PSet_Mass_Property - Area Measure: 2.5857662810171611; Mass Measure: 37.5938799840033511; Volume Measure: 0.0344570229103941

# IfcBuilding, default Building
SOLIDWORKS Custom Properties - WEIGHT: 37.59
PSet_Mass_Property - Area Measure: 2.5857662810171611; Mass Measure: 37.5938799840033511; Volume Measure: 0.0344570229103941

# IfcBuildingStorey, default BuildingStorey
In: default Building
SOLIDWORKS Custom Properties - WEIGHT: 37.59
PSet_Mass_Property - Area Measure: 2.5857662810171611; Mass Measure: 37.5938799840033511; Volume Measure: 0.0344570229103941

# IfcBuildingElementProxy: AECARCHITECTURALELEMENT (9)
In: default BuildingStorey
SOLIDWORKS Custom Properties - Finish: Unchecked
Name | DESCRIPTION | Material | WEIGHT
Part5^BENCH 2 | Part5^BENCH 2 | IROKO | 4.27
Part5^BENCH 2-1 | Part5^BENCH 2 | IROKO | 4.27
Part5^BENCH 2-2 | Part5^BENCH 2 | IROKO | 4.27
Part5^BENCH 2-3 | Part5^BENCH 2 | IROKO | 4.27
Part6^BENCH 2 | Part6^BENCH 2 | MILD STEEL | 7.76
Part5^BENCH 2-4 | Part5^BENCH 2 | IROKO | 4.27
Part7^BENCH 2 | Part7^BENCH 2 | MILD STEEL | 0.35
Part6^BENCH 2-1 | Part6^BENCH 2 | MILD STEEL | 7.76
Part7^BENCH 2-1 | Part7^BENCH 2 | MILD STEEL | 0.35

# IfcElementAssembly, BENCH 2
In: default BuildingStorey
SOLIDWORKS Custom Properties - WEIGHT: 37.59
PSet_Mass_Property - Area Measure: 2.5857662810171611; Mass Measure: 37.5938799840033511; Volume Measure: 0.0344570229103941
