Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\SOLIDWORKS WORKING\00-KINLEY\BENCHES\BENCH 3.IFC
Time: 2026-05-01T10:10:53+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
SOLIDWORKS Custom Properties - WEIGHT: 30.39
PSet_Mass_Property - Area Measure: 2.6363319932661016; Mass Measure: 30.3910597108671610; Volume Measure: 0.0335547512449830

# IfcBuilding, default Building
SOLIDWORKS Custom Properties - WEIGHT: 30.39
PSet_Mass_Property - Area Measure: 2.6363319932661016; Mass Measure: 30.3910597108671610; Volume Measure: 0.0335547512449830

# IfcBuildingStorey, default BuildingStorey
In: default Building
SOLIDWORKS Custom Properties - WEIGHT: 30.39
PSet_Mass_Property - Area Measure: 2.6363319932661016; Mass Measure: 30.3910597108671610; Volume Measure: 0.0335547512449830

# IfcBuildingElementProxy: AECARCHITECTURALELEMENT (7)
In: default BuildingStorey
SOLIDWORKS Custom Properties - Finish: Unchecked
Name | DESCRIPTION | Material | WEIGHT
Part8^BENCH 3 | Part8^BENCH 3 | IROKO | 4.28
Part8^BENCH 3-1 | Part8^BENCH 3 | IROKO | 4.28
Part8^BENCH 3-2 | Part8^BENCH 3 | IROKO | 4.28
Part8^BENCH 3-3 | Part8^BENCH 3 | IROKO | 4.28
Part8^BENCH 3-4 | Part8^BENCH 3 | IROKO | 4.28
Part9^BENCH 3 | Part9^BENCH 3 | MILD STEEL | 4.50
Part9^BENCH 3-1 | Part9^BENCH 3 | MILD STEEL | 4.50

# IfcElementAssembly, BENCH 3
In: default BuildingStorey
SOLIDWORKS Custom Properties - WEIGHT: 30.39
PSet_Mass_Property - Area Measure: 2.6363319932661016; Mass Measure: 30.3910597108671610; Volume Measure: 0.0335547512449830
